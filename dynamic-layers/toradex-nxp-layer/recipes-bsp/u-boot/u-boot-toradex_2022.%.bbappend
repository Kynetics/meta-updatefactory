FILESEXTRAPATHS:prepend:verdin-imx8mp := "${THISDIR}/files:"

SRC_URI:append:verdin-imx8mp = " \
	file://0001-Add-double-copy-support-for-verdin-imx8mp.patch \
"