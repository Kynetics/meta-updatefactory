FILESEXTRAPATHS:prepend:verdin-imx8mp := "${THISDIR}/${PN}:"

SRC_URI = " \
    file://boot.cmd.in \
"