RPROVIDES:${PN}-env = "u-boot-env"
