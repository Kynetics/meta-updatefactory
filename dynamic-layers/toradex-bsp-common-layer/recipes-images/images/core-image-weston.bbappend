IMAGE_INSTALL:append:verdin-imx8mp = " packagegroup-base-tdx-cli"
