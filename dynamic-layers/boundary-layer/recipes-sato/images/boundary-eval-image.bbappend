require ../../recipes-images/images/swupdate-regular.inc
