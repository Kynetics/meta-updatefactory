include swupdate-uf.inc