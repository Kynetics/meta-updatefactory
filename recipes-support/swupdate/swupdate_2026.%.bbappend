include swupdate-uf.inc
