SUMMARY = "SWUpdate update image for core-image-weston"

require swu-image.inc

UF_IMAGE = "core-image-weston"
