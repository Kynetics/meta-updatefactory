require swupdate-regular.inc

IMAGE_INSTALL_append = " weston-background"
