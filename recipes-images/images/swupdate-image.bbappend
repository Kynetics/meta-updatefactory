IMAGE_FSTYPES = "cpio.gz.u-boot"

require swupdate-recovery.inc
