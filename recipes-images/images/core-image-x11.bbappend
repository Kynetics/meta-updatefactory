require swupdate-regular.inc

IMAGE_FEATURES:remove = "splash"
